		AREA ARM, CODE, READONLY
		ENTRY
IO1PIN EQU 0xE0028010
IO1DIR EQU 0xE0028018
IO0PIN EQU 0xE0028000
IO0SET EQU 0xE0028004
IO0CLR EQU 0xE002800C
IO0DIR EQU 0xE0028008
	
	   LDR R4, =IO0DIR
	   LDR R5, =0x000F0000;saida leds
	   STR R5, [R4]
	
	   LDR R4, =IO1DIR
	   LDR R5, =0xFFFEFFFF;chave
	   STR R5, [R4]

COMP   LDR R9, =IO1PIN
	   LDR R4, [R9]
	   AND R4, #0x00010000
	   CMP R4, #0x00010000
	   BEQ Ligar
CLEAR  LDR R4, =IO0CLR
	   STR R5, [R4]
	   B COMP
		   
Ligar  LDR R4, =IO0SET
	   STR R5, [R4]
	   B CLEAR
	   END